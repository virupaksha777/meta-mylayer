include libmodbus.inc

SRCREV="f9fe3b0a5343f7fbb3f5c74196bd0fce88df39d5"
