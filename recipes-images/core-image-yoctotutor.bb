require recipes-core/images/core-image-minimal.bb

IMAGE_INTSALL_append ="\
	hello \
"