inherit core-image

IMAGE_INSTALL += "\
		hello \
		libmodbus \
		hellocpp \
		hellomake \
	"